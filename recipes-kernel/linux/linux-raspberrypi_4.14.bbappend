FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://hometec-rpi.cfg"